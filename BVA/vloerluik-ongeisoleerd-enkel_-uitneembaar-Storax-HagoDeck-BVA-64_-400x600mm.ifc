Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 60480bd8-ac48-4630-8da0-986684b354ae.ifc
Time: 2026-09-11T11:19:07
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcWindow, vloerluik ongeïsoleerd enkel, uitneembaar Storax - HagoDeck BVA 64, 400x600mm
In: Bouwlaag
Material: aluminium
Pset_WindowCommon - Rc-waarde: 0 m²·k/w
Pset_Data - WUID: AgAAAJkmptEDAAAA3FkBAAV2SgAA2FMBAFJfAQDxgwAA11gBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAAJkmptEDAAAA3FkBAAV2SgAA2FMBAFJfAQDxgwAA11gBAAIA6gcBAQAAAAEAAADlBwEBAAAAAgAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAA)); gewicht per st: 9 kg/st; STABU2: 43.31.10; dagmaatlengte: 400 mm; lengte: 520 mm; NAA.K.T: samengesteld_product_kozijn; breedte: 720 mm; Rc-waarde: 0 m²·k/w; serie: HagoDeck; afsluitbaar: True; hoogte: 76,5 mm; merk: Storax; breuklast: B125; type: BVA 64; dagmaatbreedte: 600 mm; omranding: aluminium; luik: aluminium
